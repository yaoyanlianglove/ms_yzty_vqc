# Keil uVision project yzty.uvprojx, settings and files
target yzty_DC_M_584_120_17_VQC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: yzty_DC_M_584_120_17_VQC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\OS_CONFIG;..\Middlewares\LiteOS\arch\arm\arm-m\include;..\Middlewares\LiteOS\kernel\include;..\Middlewares\LiteOS\kernel\base\include;..\Middlewares\LiteOS\kernel\extended\include;..\Inc\auto;..\Inc\clock;..\Inc\comm;..\Inc\comm\modbus;..\Inc\comm\private_comm;..\Inc\i2c_soft;..\Inc\LCD;..\Inc\led;..\Inc\remote_signal;..\Inc\storage;..\Inc\storage\fram;..\Inc\switch;..\Inc\telemetry;..\Inc\telemetry\AC_sampling;..\Inc\telemetry\AC_sampling\att7022;..\Inc\telemetry\oil_temp;..\Inc\switch\DC_M_584_120_17_VQC
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: crc.c debug.c delay.c task.c yzty.c main.c gpio.c iwdg.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Src/auto/: auto.c
    ../Src/clock/: clock.c
    ../Src/comm/modbus/: modbus.c modbus_interface.c
    ../Src/comm/private_comm/: private_comm.c private_comm_interface.c
    ../Src/comm/: comm_uart_callback.c
    ../Src/i2c_soft/: i2c_soft.c
    ../Src/LCD/: font.c lcd.c
    ../Src/led/: led.c
    ../Src/remote_signal/: remote_signal.c
    ../Src/storage/fram/: fram.c
    ../Src/storage/: storage.c
    ../Src/telemetry/AC_sampling/att7022/: att7022.c
    ../Src/telemetry/AC_sampling/: ac_sample.c
    ../Src/telemetry/oil_temp/: oil_temp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/LiteOS/arch
    ../Middlewares/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../Middlewares/LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group Middlewares/LiteOS/kernel
    ../Middlewares/LiteOS/kernel/: los_init.c
    ../Middlewares/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Middlewares/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Middlewares/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../Middlewares/LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../Middlewares/LiteOS/kernel/base/mem/membox/: los_membox.c
    ../Middlewares/LiteOS/kernel/base/misc/: los_misc.c
    ../Middlewares/LiteOS/kernel/base/om/: los_err.c
  group Application/Switch/DC_M_584_120_17_VQC
    ../Src/switch/DC_M__584_120_17_VQC/: motor.c switch.c switch_driver.c
software components: CMSIS:CORE 5.0.1
